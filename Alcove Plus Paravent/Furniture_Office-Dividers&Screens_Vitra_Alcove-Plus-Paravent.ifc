Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-05-18T18:16:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 18 18:16:39 2021 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{F9FF8548-0B09-4854-906C-F8A8D7A03C17}\ifc * Database version: 5507 * Database creation date: Tue May 18 18:16:39 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 18 18:16:39 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 18 18:16:39 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Alcove Plus Paravament, Furniture_Office-Dividers&Screens_Vitra_Alcove-Plus-Paravent:Alcove Plus Paravament:423871
In: Level 1
Type - ElementType: Alcove Plus Paravament; Material: 01 chrome, Textile laser yellow pastel green 23
Type - Dimensions - NominalDepth: 814.992 mm; NominalHeight: 1367 mm; NominalLength: 90 mm
Type - General - Author: BIMStone; BIMObjectName: Furniture_Office-Dividers&Screens_Vitra_Alcove-Plus-Paravent; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Panel partitions; NBSReference: 45-35-80/420; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_25_71_57_60; Uniclass2015Description: Partition panels; Uniclass2015Reference: Pr_25_71_57_60; Version: 1; VersionDate: 07/05/2021
Type - Identity Data - Collection: Alcove Plus; Cost: 0; Designer: Ronan & Erwan Bouroullec; Manufacturer: Vitra; Model: Alcove Plus Paravament; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Type Name: Alcove Plus Paravament
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Office-Dividers&Screens_Vitra_Alcove-Plus-Paravent; Features: n/a; Finish: n/a; Grade: n/a; Material: Polyurethane foam, polyester fibre & steel; ModelNumber: n/a; ModelReference: n/a; Name: Alcove-Plus-Paravent; ReplacementCost: n/a; Shape: Sculptured; Size: 90x815x1367 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.31126 m2; Volume: 0.10027 m3
Materials and Finishes - CoverMaterial: Textile laser yellow pastel green 23; FrameMaterial: 01 chrome
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Furniture_Office-Dividers&Screens_Vitra_Alcove-Plus-Paravent: Alcove Plus Paravament; Family and Type: Furniture_Office-Dividers&Screens_Vitra_Alcove-Plus-Paravent: Alcove Plus Paravament; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Office-Dividers&Screens_Vitra_Alcove-Plus-Paravent: Alcove Plus Paravament; Type Id: Furniture_Office-Dividers&Screens_Vitra_Alcove-Plus-Paravent: Alcove Plus Paravament; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
